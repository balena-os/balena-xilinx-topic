# Flash to internal eMMC - kernel always enumerates emmc as mmcblk2
INTERNAL_DEVICE_KERNEL_zcu102-zynqmp = "mmcblk2"
