RDEPENDS_${PN} += "mtd-utils \
"
